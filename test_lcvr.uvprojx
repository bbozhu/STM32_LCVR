# Keil uVision project test_lcvr.uvprojx, settings and files
target test lcvr (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: template +hex
  c flags: Optim=1 uC99=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: .\CORE;.\USER;.\STM32F10x_FWLib\inc;.\SYSTEM\delay;.\SYSTEM\sys;.\SYSTEM\usart;.\BOARD\led;.\BOARD\key;.\BOARD\tft;.\BOARD\encoder;.\BOARD\TIM;.\BOARD\I2C;.\BOARD\24CXX;.\BOARD\spi
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CORE
    ./CORE/: core_cm3.c startup_stm32f10x_md.s
  group USER
    ./USER/: main.c stm32f10x_it.c system_stm32f10x.c
  group FWLIB
    ./STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_exti.c stm32f10x_tim.c stm32f10x_dma.c
  group SYSTEM
    ./SYSTEM/delay/: delay.c
    ./SYSTEM/sys/: sys.c
    ./SYSTEM/usart/: usart.c
  group BOARD
    ./BOARD/key/: key.c
    ./BOARD/tft/: tft.c font.c
    ./BOARD/encoder/: encoder.c
    ./BOARD/TIM/: timer.c
    ./BOARD/24CXX/: _24cxx.c
    ./BOARD/I2C/: iic.c
    ./BOARD/spi/: spi.c
    ./BOARD/led/: led.c
software components: CMSIS:CORE 4.1.0
